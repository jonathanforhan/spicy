** Design1 **
*
* NI Multisim to SPICE Netlist Export
* Generated by: jon
* Sun, Mar 09, 2025 16:44:53
*

*## Multisim Component R1 ##*
rR1 1 0 1000 vresR1
.model vresR1 r(  )

*## Multisim Component V1 ##*
vV1 1 0 dc 12 ac 0 0
+           distof1 0 0
+           distof2 0 0
